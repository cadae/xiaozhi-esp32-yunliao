## sdkconfig.defaults.esp32c3
```kconfig
CONFIG_ESPTOOLPY_FLASHSIZE_8MB=y
CONFIG_WIFI_FACTORY_SSID=xiaozhi
CONFIG_WIFI_FACTORY_PASSWORD=123456789
```
